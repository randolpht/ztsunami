# Keil uVision project zTsunami.uvproj, settings and files
target Target 1 (MCS-51)
  device: CC1110F32 Texas Instruments
  cpu: IRAM(0-0xFE) XRAM(0xF000-0xFEFF) IROM(0-0x7FFF) CLOCK(26000000) MODC2
  output: zTsunami +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: zTsunami.c Info.c Radio.c UART.c Util.c
